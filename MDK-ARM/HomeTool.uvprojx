# Keil uVision project HomeTool.uvprojx, settings and files
target HomeTool (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HomeTool +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; .\UserCode\DHT11; .\UserCode\LCD_1602; .\UserCode\soft_iic; .\UserCode\app; .\UserCode\Gizwits; .\UserCode\Hal; .\UserCode\md5; .\UserCode\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Dht11
    ./UserCode/DHT11/: bsp_DHT11.c
  group Lcd1602
    ./UserCode/LCD_1602/: lcd_1602.c
    ./UserCode/soft_iic/: sotf_iic.c
  group Gizwits
    ./UserCode/Gizwits/: gizwits_product.c gizwits_protocol.c
  group Hal
    ./UserCode/Hal/: hal_key.c
  group Utils
    ./UserCode/Utils/: common.c dataPointTools.c ringbuffer.c
  group APP
    ./UserCode/app/: app.c
    ./UserCode/md5/: gagent_md5.c
software components: CMSIS:CORE 4.3.0
